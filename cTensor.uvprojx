# Keil uVision project cTensor.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(25000000) ESEL ELITTLE
  output: cTensor
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xfffffff
  group user
    ./user/: main.c
  group docs
    ./: Readme.txt
  group ctensor/include
    ./include/common/: vector.h
    ./include/: cten.h cten_internal.h
  group ctensor/src
    ./src/: basic.c context.c iris_dataset.c nn.c operator.c pool.c utils.c
    ./src/optimizer/: adagrad.c adam.c rmsprop.c sgd.c
    ./src/common/: vector.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.2
